<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\..\Documents and Settings\Administrator\My Documents\DST\Labb1\arduino_due_x_sram.mac</name>
  </file>
  <file>
    <name>$PROJ_DIR$\at91sam3x8.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Common_Functions.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Common_Functions.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Common_Variables.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\core_cm3.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\..\Documents and Settings\Administrator\My Documents\DST\Labb1\core_cmFunc.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\..\Documents and Settings\Administrator\My Documents\DST\Labb1\core_cmInstr.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\cstartup.s</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Display_Module.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Display_Module.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\exceptions.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\exceptions.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Keypad_Module.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Keypad_Module.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Light_Module.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Light_Module.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\startup_sam3x.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\system_sam3x.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Temp_Module.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Temp_Module.h</name>
  </file>
</project>


