# IAR project Projekt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Atmel ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Atmel\sam3x8e\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../Documents and Settings/Administrator/My Documents/DST/Labb1/: arduino_due_x_sram.mac core_cmFunc.h core_cmInstr.h
    ./: at91sam3x8.h Common_Functions.c Common_Functions.h Common_Variables.h core_cm3.h cstartup.s Display_Module.c Display_Module.h exceptions.c exceptions.h Keypad_Module.c Keypad_Module.h Light_Module.c Light_Module.h main.c startup_sam3x.c system_sam3x.c Temp_Module.c Temp_Module.h
